## fcc_app/tests/test_tracking/testcase.yaml
```yaml
tests:
  fcc_app.tracking:
    platform_allow:
      - native_sim
    integration_platforms:
      - native_sim
    tags:
      - tracking
```
