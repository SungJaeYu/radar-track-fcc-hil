## fcc_app/tests/test_kalman/testcase.yaml
```yaml
tests:
  fcc_app.kalman:
    platform_allow:
      - native_sim
    integration_platforms:
      - native_sim
    tags:
      - kalman
```
